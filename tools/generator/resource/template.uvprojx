# Keil uVision project template.uvprojx, settings and files
target SP28038 (6220000::V6.22::ARMCLANG)
  device: SP28038 STARPOWER
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SP28038
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .\core\inc\csp;.\hal\libraries\Utilities;.\hal\libraries\Utilities\retarget;.\hal\libraries\cmsis\inc;.\hal\libraries\std_drivers\inc;.\hal\libraries\std_drivers\src;core/inc;hal/libraries/cmsis/device;hal/libraries/cmsis/inc;hal/libraries/std_drivers/inc
  library: MicroLIB
  link misc: --remove --entry=Reset_Handler
